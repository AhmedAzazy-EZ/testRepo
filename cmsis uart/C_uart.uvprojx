# Keil uVision project C_uart.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: C_uart +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.4.0, CMSIS Driver:USART 2.13, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
